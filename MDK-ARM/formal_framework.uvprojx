# Keil uVision project formal_framework.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: formal_framework +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: ..\Core\Inc;..\Debug\Inc;..\Bsp\Inc;..\Sensor\Inc;..\Driver\Comm\Inc;..\Framework\Inc;..\Business\Inc;..\Display\Inc;..\Storage\Inc;..\Third_Party\LVGL;..\Third_Party\LVGL\src;..\Third_Party\FatFs;..\Third_Party\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Third_Party\Drivers\STM32F4xx_HAL_Driver\Inc;..\Third_Party\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Third_Party\Middlewares\Source\include;..\Third_Party\Middlewares\Source\portable\RVDS\ARM_CM4F;..\Third_Party\Drivers\CMSIS\Include;..\Third_Party\mavlink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c freertos_hooks.c
  group Framework
    ../Framework/Src/: px4lite_app.c px4lite_storage.c px4lite_modules.c px4lite_mavlink_tx.c px4lite_remoteid_tx.c px4lite_identity.c px4lite_mavlink_rx.c px4lite_command.c px4lite_attitude.c px4lite_alarm.c px4lite_time.c px4lite_control.c px4lite_topics.c px4lite_platform_f407.c px4lite_remote_telemetry.c px4lite_local_msglog.c px4lite_registry.c px4lite_work.c px4lite_recovery.c
  group Business
    ../Business/Src/: business_event_bus.c business_task_template.c business_task_registry.c business_platform_adapter.c business_display_placeholder.c app_data_api.c app_message_log.c
  group Device Driver
    ../Sensor/Src/: sensor_gnss.c sensor_nmea.c sensor_bme280.c sensor_mpu6050.c sensor_power.c sensor_power2.c
    ../Driver/Comm/Src/: lora_e22.c
  group BSP
    ../Bsp/Src/: bsp.c bsp_uart.c bsp_gnss.c bsp_rtc.c bsp_lora.c bsp_remoteid.c bsp_lcd_fsmc.c bsp_touch_port.c bsp_i2c.c bsp_adc.c bsp_adc2.c bsp_time.c bsp_spi.c bsp_pwm.c bsp_button.c
  group Display
    ../Display/Src/: display.c display_gt911.c display_logo.c display_ssd1963.c display_lvgl.c display_lvgl_font_zh.c lv_port_disp.c lv_port_indev.c
  group LVGL
    ../Third_Party/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Third_Party/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Third_Party/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Third_Party/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Third_Party/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Third_Party/LVGL/src/extra/: lv_extra.c
    ../Third_Party/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Third_Party/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Third_Party/LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_24.c
    ../Third_Party/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Third_Party/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Third_Party/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_img.c lv_label.c lv_line.c lv_slider.c
  group Debug
    ../Debug/Src/: debug_console.c debug_task_monitor.c debug_service.c debug_selftest.c
  group HAL
    ../Third_Party/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group FreeRTOS
    ../Third_Party/Middlewares/Source/: list.c queue.c tasks.c timers.c
    ../Third_Party/Middlewares/Source/portable/MemMang/: heap_4.c
    ../Third_Party/Middlewares/Source/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ../Third_Party/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Storage
    ../Storage/Src/: storage_sd.c storage_csv.c storage_queue.c diskio_sd_spi.c
    ../Third_Party/FatFs/: ff.c
